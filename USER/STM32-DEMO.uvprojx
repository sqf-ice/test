# Keil uVision project STM32-DEMO.uvprojx, settings and files
target USART1-DEMO (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;.\src;.\src\PN532;.\src\TDA8029
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c
    ./src/: bsp_led.c bsp_serial.c cpucard_deposit.c msg_process.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_dma.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group pn532
    ./src/PN532/: pn532_dev.c nfc.c
    ./src/: FM1208.C FM1208-z.c ISO14443A.C
  group tda8029
    ./src/TDA8029/: T8029.c atr.c psam1.c
  group common
    ./src/: fifo.c des.c encryption.c mirror-subr.c
software components: CMSIS:CORE 5.0.0
